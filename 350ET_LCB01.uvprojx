# Keil uVision project 350ET_LCB01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: N32G435KB NSING
  pack: NSING.N32G43x_DFP.0.9.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 350ET_LCB01
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c main.h
